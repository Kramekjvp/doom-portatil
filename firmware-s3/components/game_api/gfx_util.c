/*
 * Utilitarios graficos portateis: fonte 5x7 (maiusculas, numeros e alguns
 * sinais; minusculas sao desenhadas como maiusculas), texto escalavel e
 * retangulo arredondado. Tudo sai por gfx_blit / gfx_fill_rect.
 *
 * Cada glifo e enviado como um unico blit (celula 6x8 * escala), entao o
 * buffer de trabalho e pequeno e fixo: nada de malloc.
 */
#include <string.h>
#include "gfx.h"

/* 7 linhas por glifo, 5 bits por linha (bit 4 = pixel da esquerda) */
#define G(c) [(c) - 32]
static const uint8_t FONT[59][7] = {
    G(' ') = {0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00},
    G('!') = {0x04, 0x04, 0x04, 0x04, 0x04, 0x00, 0x04},
    G('\'') = {0x04, 0x04, 0x08, 0x00, 0x00, 0x00, 0x00},
    G('(') = {0x02, 0x04, 0x08, 0x08, 0x08, 0x04, 0x02},
    G(')') = {0x08, 0x04, 0x02, 0x02, 0x02, 0x04, 0x08},
    G('+') = {0x00, 0x04, 0x04, 0x1F, 0x04, 0x04, 0x00},
    G(',') = {0x00, 0x00, 0x00, 0x00, 0x0C, 0x04, 0x08},
    G('-') = {0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00},
    G('.') = {0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x0C},
    G('/') = {0x01, 0x01, 0x02, 0x04, 0x08, 0x10, 0x10},
    G('0') = {0x0E, 0x11, 0x13, 0x15, 0x19, 0x11, 0x0E},
    G('1') = {0x04, 0x0C, 0x04, 0x04, 0x04, 0x04, 0x0E},
    G('2') = {0x0E, 0x11, 0x01, 0x02, 0x04, 0x08, 0x1F},
    G('3') = {0x1F, 0x02, 0x04, 0x02, 0x01, 0x11, 0x0E},
    G('4') = {0x02, 0x06, 0x0A, 0x12, 0x1F, 0x02, 0x02},
    G('5') = {0x1F, 0x10, 0x1E, 0x01, 0x01, 0x11, 0x0E},
    G('6') = {0x06, 0x08, 0x10, 0x1E, 0x11, 0x11, 0x0E},
    G('7') = {0x1F, 0x01, 0x02, 0x04, 0x08, 0x08, 0x08},
    G('8') = {0x0E, 0x11, 0x11, 0x0E, 0x11, 0x11, 0x0E},
    G('9') = {0x0E, 0x11, 0x11, 0x0F, 0x01, 0x02, 0x0C},
    G(':') = {0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x0C, 0x00},
    G('<') = {0x02, 0x04, 0x08, 0x10, 0x08, 0x04, 0x02},
    G('=') = {0x00, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00},
    G('>') = {0x08, 0x04, 0x02, 0x01, 0x02, 0x04, 0x08},
    G('?') = {0x0E, 0x11, 0x01, 0x02, 0x04, 0x00, 0x04},
    G('A') = {0x0E, 0x11, 0x11, 0x1F, 0x11, 0x11, 0x11},
    G('B') = {0x1E, 0x11, 0x11, 0x1E, 0x11, 0x11, 0x1E},
    G('C') = {0x0E, 0x11, 0x10, 0x10, 0x10, 0x11, 0x0E},
    G('D') = {0x1C, 0x12, 0x11, 0x11, 0x11, 0x12, 0x1C},
    G('E') = {0x1F, 0x10, 0x10, 0x1E, 0x10, 0x10, 0x1F},
    G('F') = {0x1F, 0x10, 0x10, 0x1E, 0x10, 0x10, 0x10},
    G('G') = {0x0E, 0x11, 0x10, 0x17, 0x11, 0x11, 0x0F},
    G('H') = {0x11, 0x11, 0x11, 0x1F, 0x11, 0x11, 0x11},
    G('I') = {0x0E, 0x04, 0x04, 0x04, 0x04, 0x04, 0x0E},
    G('J') = {0x07, 0x02, 0x02, 0x02, 0x02, 0x12, 0x0C},
    G('K') = {0x11, 0x12, 0x14, 0x18, 0x14, 0x12, 0x11},
    G('L') = {0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x1F},
    G('M') = {0x11, 0x1B, 0x15, 0x15, 0x11, 0x11, 0x11},
    G('N') = {0x11, 0x11, 0x19, 0x15, 0x13, 0x11, 0x11},
    G('O') = {0x0E, 0x11, 0x11, 0x11, 0x11, 0x11, 0x0E},
    G('P') = {0x1E, 0x11, 0x11, 0x1E, 0x10, 0x10, 0x10},
    G('Q') = {0x0E, 0x11, 0x11, 0x11, 0x15, 0x12, 0x0D},
    G('R') = {0x1E, 0x11, 0x11, 0x1E, 0x14, 0x12, 0x11},
    G('S') = {0x0F, 0x10, 0x10, 0x0E, 0x01, 0x01, 0x1E},
    G('T') = {0x1F, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04},
    G('U') = {0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x0E},
    G('V') = {0x11, 0x11, 0x11, 0x11, 0x11, 0x0A, 0x04},
    G('W') = {0x11, 0x11, 0x11, 0x15, 0x15, 0x15, 0x0A},
    G('X') = {0x11, 0x11, 0x0A, 0x04, 0x0A, 0x11, 0x11},
    G('Y') = {0x11, 0x11, 0x0A, 0x04, 0x04, 0x04, 0x04},
    G('Z') = {0x1F, 0x01, 0x02, 0x04, 0x08, 0x10, 0x1F},
};
#undef G

static const uint8_t FONT_BOX[7] = {0x1F, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1F};

/* celula 6x8 em escala maxima */
static uint16_t s_glyph[(GFX_FONT_W * GFX_TEXT_MAX_SCALE) * (GFX_FONT_H * GFX_TEXT_MAX_SCALE)]
    __attribute__((aligned(4)));

static const uint8_t *glyph_rows(char c)
{
    if (c >= 'a' && c <= 'z') c = (char)(c - 32);
    if (c < 32 || c > 90) return FONT_BOX;
    const uint8_t *g = FONT[c - 32];
    if (c != ' ' && !(g[0] | g[1] | g[2] | g[3] | g[4] | g[5] | g[6])) return FONT_BOX;
    return g;
}

int gfx_text_width(const char *s, int scale)
{
    if (scale < 1) scale = 1;
    if (scale > GFX_TEXT_MAX_SCALE) scale = GFX_TEXT_MAX_SCALE;
    return (int)strlen(s) * GFX_FONT_W * scale;
}

void gfx_text(int x, int y, const char *s, int scale, uint16_t fg, uint16_t bg)
{
    if (scale < 1) scale = 1;
    if (scale > GFX_TEXT_MAX_SCALE) scale = GFX_TEXT_MAX_SCALE;
    const int cw = GFX_FONT_W * scale, ch = GFX_FONT_H * scale;

    for (; *s; s++, x += cw) {
        const uint8_t *rows = glyph_rows(*s);
        for (int py = 0; py < ch; py++) {
            int gy = py / scale;                       /* linha 0..7 do glifo */
            for (int px = 0; px < cw; px++) {
                int gx = px / scale;                   /* coluna 0..5         */
                int on = (gy < 7 && gx < 5) && ((rows[gy] >> (4 - gx)) & 1);
                s_glyph[py * cw + px] = on ? fg : bg;
            }
        }
        gfx_blit(x, y, cw, ch, s_glyph);
    }
}

void gfx_text_transparent(int x, int y, const char *s, int scale, uint16_t fg)
{
    if (scale < 1) scale = 1;
    if (scale > GFX_TEXT_MAX_SCALE) scale = GFX_TEXT_MAX_SCALE;
    const int cw = GFX_FONT_W * scale;

    for (; *s; s++, x += cw) {
        const uint8_t *rows = glyph_rows(*s);
        for (int gy = 0; gy < 7; gy++) {
            int gx = 0;
            while (gx < 5) {
                if (!((rows[gy] >> (4 - gx)) & 1)) { gx++; continue; }
                int ini = gx;
                while (gx < 5 && ((rows[gy] >> (4 - gx)) & 1)) gx++;
                gfx_fill_rect(x + ini * scale, y + gy * scale, (gx - ini) * scale, scale, fg);
            }
        }
    }
}

void gfx_text_centered(int cx, int y, const char *s, int scale, uint16_t fg, uint16_t bg)
{
    gfx_text(cx - gfx_text_width(s, scale) / 2, y, s, scale, fg, bg);
}

/* Retangulo com cantos "mordidos" (raio ~2 px): 3 fill_rects, bem barato */
void gfx_fill_round_rect(int x, int y, int w, int h, uint16_t color)
{
    if (w < 6 || h < 6) { gfx_fill_rect(x, y, w, h, color); return; }
    gfx_fill_rect(x + 2, y,     w - 4, h,     color);
    gfx_fill_rect(x,     y + 2, w,     h - 4, color);
    gfx_fill_rect(x + 1, y + 1, w - 2, h - 2, color);
}
